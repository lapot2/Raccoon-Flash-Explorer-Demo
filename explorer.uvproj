# Keil uVision project explorer.uvproj, settings and files
target Raccoon Flash Explorer Demo (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: explorer +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source files
    ./src/: main.c usb.c usb_desc.c usb_req_class.c usb_req_vendor.c usb_req_std.c util.c scsi.c memory.c i2c.c spi.c FAT_PBR.c ROOT_ENTRIES.c pin_checker.c hw_monitor.c scsi_rw_parser.c spi_name_gen.c rfe_params.c bit_seek.c FAT_MBR.c sound.c errors_collector.c interrupts.c hw_init.c port_mode_switch.c sfdp.c
  group Header files
    ./src/: sfdp.h rfe_params.h bit_seek.h config.h errors_collector.h hw_monitor.h i2c.h interrupts.h main.h memory.h my_code.h pin_checker.h scsi.h scsi_rw_parser.h sound.h spi.h stc.h STC8H.h usb.h usb_desc.h usb_req_class.h usb_req_std.h usb_req_vendor.h util.h hw_init.h adc_defs.h cmp_defs.h rtc_defs.h power_control_defs.h port_mode_switch.h HTML_PAGE.h
  group Assembly files
    ./src/: bit_seek_read.a51 bit_seek_save.a51 string_table.a51 util_asm.a51 port_mode_switch_asm.a51 spi_id_remappper.a51 spi_util_asm.a51
